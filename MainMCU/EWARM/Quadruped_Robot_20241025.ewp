# IAR project Quadruped_Robot_20241025.ewp, settings and files
configuration Quadruped_Robot_20241025 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\User\DeepJ60; ../FATFS/Target; ../FATFS/App; ../Middlewares/Third_Party/FatFs/src; ..\User\LogSystem; ..\User\GaitController; ..\User\CurvePlan; ..\User\KinematicSolution
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Quadruped_Robot_20241025.hex
  ILINK.IlinkOutputFile: Quadruped_Robot_20241025.out
  ILINK.IlinkIcfFile: stm32f427xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: can.c gpio.c main.c sdio.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c user_diskio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: cc936.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group User
    ../User/: Callback.c
    ../User/CurvePlan/: CurvePlan.c
    ../User/GaitController/: GaitController.c
    ../User/KinematicSolution/: KinematicSolution.c
    ../User/LogSystem/: LogSystem.c
  group User/DeepJ60
    ../User/DeepJ60/: DeepJ60_can.c DeepJ60_Motor.c
