<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Quadruped_Robot_20241025.ewp</path>
  </project>
  <batchBuild />
</workspace>
