<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\spi_to_can_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
