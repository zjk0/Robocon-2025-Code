# IAR project zhukongv2.ewp, settings and files
configuration zhukongv2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427VI ST STM32F427VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\User; ..\User\CurvePlan; ..\User\DeepJ60; ..\User\GaitController; ..\User\KinematicSolution; ..\User\LogSystem; ../FATFS/Target; ../FATFS/App; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ..\User\Handle; ..\User\IMU; ..\User\NRF; ..\User\Camera
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: zhukongv2.hex
  ILINK.IlinkOutputFile: zhukongv2.out
  ILINK.IlinkIcfFile: stm32f427xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c user_diskio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group User
    ../User/: Callback.c
    ../User/Camera/: Camera.c
    ../User/CurvePlan/: CurvePlan.c
    ../User/KinematicSolution/: foot_attitude_calculation.c KinematicSolution.c
    ../User/GaitController/: GaitController.c
    ../User/Handle/: Handle.c
    ../User/IMU/: imu.c
    ../User/LogSystem/: LogSystem.c
    ../User/NRF/: nrf.c
  group User/DeepJ60
    ../User/DeepJ60/: DeepJ60_can.c DeepJ60_Motor.c
